Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView], Option [BaseQuantities:On], Option [GridExport:Off], Option [Assemblies:On], Option [Bolts:On], Option [Rebars:On], Option [PourObjects:Off], Option [Welds:On], Option [SurfaceTreatments:On], Option [LocationBy:0], Option [ViewColors:On], Option [SectionedSpine:Off], Option [PropertySets:On], Option [Export all:Off]
File name: TR3033433DIN 800x270 Thvz.ifc
Time: 2019-03-12T08:57:27
Author: ROTOGROEP\p.thissen
Organization: Structural Designer
Written by: IFC Database version: Work
Made in: Tekla Structures Educational 2018i Service Pack 2, IFC Export Version: 4.0.0.0 Jan 23 2019

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: PL2*800, BEAM
In: Undefined
Description: PL2*800; Material: Undefined/Undefined
Default - NAME: BEAM
Tekla Common - Bottom elevation: -0.035; Top elevation: +0.003; Phase: 1; Class: 1
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0.1 m2; Height: 800 mm; Width: 62.6 mm; Length: 58.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: P0(?)
BaseQuantities - Length: 58.3711 mm; OuterSurfaceArea: 0.104649 m2; NetVolume: 0.0000991854 m3; NetWeight: 0 kg

# IfcElementAssembly (4)
In: Undefined
Tekla Assembly - Assembly/Cast unit weight: 0 kg; Assembly/Cast unit Mark: A0(?)
Name | Assembly/Cast unit bottom elevation | Assembly/Cast unit top elevation | Assembly/Cast unit position code | Width (mm)
PLATE | -0.070 | +0.003 | B-C/2-3 | 73
PLATE | -0.070 | +0.000 | B-C/2-3 | 3
PLATE | -0.070 | +0.000 | B-C/2 | 3
BEAM | -0.035 | +0.003 | B-C/2-3 | 34.9795

# IfcMechanicalFastener: Bolt assembly (4)
In: Undefined
NominalDiameter: 12 mm; NominalLength: 3 mm; Material: Undefined
Tekla Bolt - Washer count: 0; Washer diameter: 12 mm; Washer type: 7089; Washer name: RING-M12-7089; Nut count: 0; Nut type: 4032; Nut name: MOER-M12-4032; Slotted hole y: 0 mm; Bolt hole diameter: 13 mm; Location: Montage; Bolt count: 1; Bolt size: 13 mm; Bolt length: 3 mm; Bolt standard: 4014-8.8; Bolt Name: BOUT
Name | Slotted hole x (mm)
2 x Bolt assembly | 20
2 x Bolt assembly | 0

# IfcPlate: PL25*241.5, PLATE
In: Undefined
Description: PL25*241.5; Material: Undefined/Undefined
Default - NAME: PLATE
Pset_PlateCommon - LoadBearing: yes; Reference: P0(?)
Tekla Common - Bottom elevation: -0.025; Top elevation: +0.000; Phase: 1; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0.2 m2; Area per tons: 0 m2; Net surface area: 0.4 m2; Height: 241.5 mm; Width: 25 mm; Length: 794 mm
BaseQuantities - Width: 241.5 mm; NetArea: 0.435277 m2; GrossArea: 0.191751 m2; CrossSectionArea: 0.000625 m2; NetVolume: 0.00479378 m3; GrossVolume: 0.00479378 m3

# IfcPlate: PL3*70 (2)
In: Undefined
Description: PL3*70; Material: Undefined/Undefined
Default - NAME: PLATE
Tekla Common - Bottom elevation: -0.070; Top elevation: +0.000; Phase: 1; Class: 99
Tekla Quantity - Weight: 0 kg; Volume: 0 m3; Gross footprint area: 0 m2; Area per tons: 0 m2; Net surface area: 0 m2; Height: 70 mm; Width: 3 mm; Length: 269 mm
Pset_PlateCommon - LoadBearing: yes; Reference: P0(?)
BaseQuantities - Width: 70 mm; NetArea: 0.0376609 m2; GrossArea: 0.01883 m2; CrossSectionArea: 0.000009 m2; NetVolume: 0.0000536145 m3; GrossVolume: 0.0000536145 m3
